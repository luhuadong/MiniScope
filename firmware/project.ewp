# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC824M201 NXP LPC824M201
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0PLUS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: rt-thread/components/libc/compilers/common; rt-thread/components/finsh; Libraries/common/chip; rt-thread/libcpu/arm/cortex-m0; drivers; rt-thread/libcpu/arm/common; Libraries/common/board; Libraries/peri_driver; .; applications; rt-thread/components/drivers/include; Libraries/common/CMSIS; rt-thread/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: lpc824_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CORE_M0PLUS
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: application.c startup.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m0/: cpuport.c context_iar.S
  group DeviceDrivers
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    drivers/: board.c usart.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c signal.c thread.c timer.c
  group Libraries
    Libraries/peri_driver/acmp/: acmp_8xx.c
    Libraries/peri_driver/adc/: adc_8xx.c
    Libraries/peri_driver/crc/: crc_8xx.c
    Libraries/peri_driver/dma/: dma_8xx.c
    Libraries/peri_driver/gpio/: gpio_8xx.c
    Libraries/peri_driver/i2c/: i2c_8xx.c
    Libraries/peri_driver/iap/: iap.c
    Libraries/peri_driver/mrt/: stopwatch.c
    Libraries/peri_driver/pinint/: pinint_8xx.c
    Libraries/peri_driver/pmu/: pmu_8xx.c
    Libraries/peri_driver/sctimer/: sct_8xx.c sct_pwm_8xx.c
    Libraries/peri_driver/spi/: spi_8xx.c
    Libraries/peri_driver/uart/: ring_buffer.c uart_8xx.c
    Libraries/peri_driver/wkt/: wkt_8xx.c
    Libraries/peri_driver/wwdt/: wwdt_8xx.c
    Libraries/common/board/: board_lpc.c
    Libraries/common/chip/: clock_8xx.c ioswm_8xx.c syscon_8xx.c sysinit_8xx.c
    Libraries/common/startup/: iar_startup_lpc82x.s
