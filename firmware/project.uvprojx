# Keil uVision project project.uvprojx, settings and files
target RT-Thread LPC82x (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.5.0
  cpu: IRAM(0x10000000,0x00002000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rtthread-lpc
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: CORE_M0PLUS
  c include: applications;.;rt-thread/libcpu/arm/common;rt-thread/libcpu/arm/cortex-m0;rt-thread/components/drivers/include;drivers;rt-thread/components/finsh;.;rt-thread/include;rt-thread/components/libc/compilers/common;Libraries/peri_driver;Libraries/common/board;Libraries/common/chip;Libraries/common/CMSIS
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\lpc824_rom.sct
  group Applications
    applications/: application.c startup.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    drivers/: board.c usart.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c signal.c thread.c timer.c
  group Libraries
    Libraries/peri_driver/acmp/: acmp_8xx.c
    Libraries/peri_driver/adc/: adc_8xx.c
    Libraries/peri_driver/crc/: crc_8xx.c
    Libraries/peri_driver/dma/: dma_8xx.c
    Libraries/peri_driver/gpio/: gpio_8xx.c
    Libraries/peri_driver/i2c/: i2c_8xx.c
    Libraries/peri_driver/iap/: iap.c
    Libraries/peri_driver/mrt/: stopwatch.c
    Libraries/peri_driver/pinint/: pinint_8xx.c
    Libraries/peri_driver/pmu/: pmu_8xx.c
    Libraries/peri_driver/sctimer/: sct_8xx.c sct_pwm_8xx.c
    Libraries/peri_driver/spi/: spi_8xx.c
    Libraries/peri_driver/uart/: ring_buffer.c uart_8xx.c
    Libraries/peri_driver/wkt/: wkt_8xx.c
    Libraries/peri_driver/wwdt/: wwdt_8xx.c
    Libraries/common/board/: board_lpc.c
    Libraries/common/chip/: clock_8xx.c ioswm_8xx.c syscon_8xx.c sysinit_8xx.c
    Libraries/common/startup/: keil_startup_lpc82x.s
software components: CMSIS:CORE 5.0.1
